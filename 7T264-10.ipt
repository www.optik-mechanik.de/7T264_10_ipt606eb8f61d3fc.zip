# Autodesk Inventor part: 7T264-10uzsakovui
## iProperties
Created: 2006-11
Part Number: 7T264-10uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
